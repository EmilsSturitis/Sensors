<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\altimeter_stm32f411_blackpill.ewp</path>
  </project>
  <batchBuild />
</workspace>
